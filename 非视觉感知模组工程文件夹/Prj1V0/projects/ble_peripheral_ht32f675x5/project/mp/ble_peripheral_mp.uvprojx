# Keil uVision project ble_peripheral_mp.uvprojx, settings and files
target ble_peripheral_mp (6240000::V6.24::ARMCLANG)
  device: HT32F67595_28LGA:CM33 Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20200000,0x00040000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ble_peripheral_mp +hex
  AfterMake: .\ble_peripheral_mp.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=7 wLevel=3
  c define: __MAIN_PROCESSOR HT32F67595_EVB
  c include: ..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\sources\device\ht32f675x5\Include;..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\register;..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hw\inc;..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hal\inc;..\..\..\..\sources\drivers\ht32f675x5_r2\ext_flash;..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hw\inc;..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hal\inc;..\..\..\..\sources\boards;..\..\..\..\sources\components\ht32f675x5_r2\app_debug;..\..\..\..\sources\components\ht32f675x5_r2\err_debug;..\..\..\..\sources\components\ht32f675x5_r2\fw_upgrade;..\..\..\..\sources\components\ht32f675x5_r2\lpwr_ctrl;..\..\..\..\sources\components\ht32f675x5_r2\rom_callback;..\..\..\..\sources\components\ht32f675x5_r2\utility;..\..\..\..\sources\components\ht32f675x5_r2\app_flash;..\..\..\..\sources\mem_cfg;..\..\..\..\sources\app;..\..\..\..\sources\ai;..\..\..\..\sources\ota;..\..\..\..\third_party\tflm-tree;..\..\..\..\third_party\tflm-tree\third_party\flatbuffers\include;..\..\..\..\third_party\tflm-tree\third_party\gemmlowp;..\..\..\..\third_party\tflm-tree\third_party\ruy;..\..\..\..\third_party\tflm-tree\tensorflow\lite\micro\cortex_m_generic;..\..\config;.\RTE\_ble_peripheral_mp;D:\Keil5\ARM\ARMCLANG\include
  asm define: __MAIN_PROCESSOR
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20200000 size 0x40000
  scatter file: .\ble_peripheral_mp.sct
  link misc: --entry=Reset_Handler --keep=g_boot2LibCode --keep=g_u8CpAppCode
  group Startup Code
    ../../../../sources/device/ht32f675x5/Source/ARM/: startup_ARMCM33.s
    ../../../../sources/device/ht32f675x5/Source/: system_ARMCM33.c
  group lib
    ../../../../libraries/rom/: ht32f675x5_rom_lib_mp_r2.lib
    ../../../../libraries/patch/: ht32f675x5_patch_lib_mp_r2.lib
    ../../../../libraries/boot2/: ht32f675x5_boot2_lib_r2_v1.1.c
  group components
    ../../../../sources/components/ht32f675x5_r2/app_debug/: app_debug.c
    ../../../../sources/components/ht32f675x5_r2/err_debug/: err_debug.c
    ../../../../sources/components/ht32f675x5_r2/lpwr_ctrl/: lpwr_ctrl.c
    ../../../../sources/components/ht32f675x5_r2/app_flash/: app_flash.c
  group main
    ../../../../sources/projects_source/ble_peripheral_ht32f675x5/main/mp/: main.c
  group ai
    ../../../../sources/ai/: model_inference.cpp
  group ota
    ../../../../sources/ota/: ota_manager.c ble_ota_service.c
  group tflm_core
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/: micro_interpreter.cc micro_allocator.cc micro_interpreter_graph.cc micro_interpreter_context.cc micro_allocation_info.cc micro_context.cc micro_op_resolver.cc micro_log.cc micro_utils.cc flatbuffer_utils.cc micro_resource_variable.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/arena_allocator/: persistent_arena_buffer_allocator.cc non_persistent_arena_buffer_allocator.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/cortex_m_generic/: micro_time.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/tflite_bridge/: micro_error_reporter.cc flatbuffer_conversions_bridge.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/core/api/: flatbuffer_conversions.cc
    ../../../../third_party/tflm-tree/tensorflow/compiler/mlir/lite/core/api/: error_reporter.cc
  group tflm_kernels
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/kernels/: conv.cc conv_common.cc depthwise_conv.cc depthwise_conv_common.cc fully_connected.cc fully_connected_common.cc pooling.cc pooling_common.cc activations.cc activations_common.cc quantize.cc quantize_common.cc dequantize.cc dequantize_common.cc reshape.cc reshape_common.cc softmax.cc softmax_common.cc elementwise.cc kernel_util.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/kernels/: kernel_util.cc
  group tflm_utils
    ../../../../third_party/tflm-tree/tensorflow/lite/kernels/internal/: tensor_utils.cc portable_tensor_utils.cc runtime_shape.cc tensor_ctypes.cc common.cc quantization_util.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/kernels/internal/reference/: portable_tensor_utils.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/core/c/: common.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/kernels/: micro_tensor_utils.cc
    ../../../../third_party/tflm-tree/tensorflow/compiler/mlir/lite/schema/: schema_utils.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/: array.cc
  group tflm_allocator
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/arena_allocator/: single_arena_buffer_allocator.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/: memory_helpers.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/memory_planner/: linear_memory_planner.cc greedy_memory_planner.cc
  group tflm_platform
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/cortex_m_generic/: debug_log.cc
    ../../../../third_party/tflm-tree/tensorflow/lite/micro/: system_setup.cc
