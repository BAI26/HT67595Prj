# Keil uVision project test_minimal.uvprojx, settings and files
target Test (ARM-ADS)
  device: HT32F67595_28LGA:CM33 Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.5
