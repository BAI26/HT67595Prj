# Keil uVision project ble_peripheral_mp.uvprojx, settings and files
target ble_peripheral_mp (6180000::V6.18::ARMCLANG)
  device: HT32F67595_28LGA:CM33 Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ble_peripheral_mp +hex
  AfterMake: .\ble_peripheral_mp.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MAIN_PROCESSOR HT32F67595_USER
  c include: ..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\..\..\sources\device\ht32f675x5\Include;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\register;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hw\inc;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hal\inc;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ext_flash;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hw\inc;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hal\inc;..\..\..\..\..\..\sources\boards;..\..\..\..\..\..\sources\components\ht32f675x5_r2\app_debug;..\..\..\..\..\..\sources\components\ht32f675x5_r2\err_debug;..\..\..\..\..\..\sources\components\ht32f675x5_r2\fw_upgrade;..\..\..\..\..\..\sources\components\ht32f675x5_r2\lpwr_ctrl;..\..\..\..\..\..\sources\components\ht32f675x5_r2\rom_callback;..\..\..\..\..\..\sources\components\ht32f675x5_r2\utility;..\..\..\..\..\..\sources\components\ht32f675x5_r2\bsp_spi;..\..\..\..\..\..\sources\components\ht32f675x5_r2\lsm6dsow;..\..\..\..\..\..\sources\components\ht32f675x5_r2\ist8310;..\..\..\..\..\..\sources\components\ht32f675x5_r2\imu9dof;..\..\..\..\..\..\sources\components\ht32f675x5_r2\ahrs;..\..\..\..\..\..\sources\components\ht32f675x5_r2\ble_sensor;..\..\..\..\..\..\sources\components\ht32f675x5_r2\ipc_general;..\..\..\..\..\..\sources\components\ht32f675x5_r2\msg_queue;..\..\..\..\..\..\sources\components\ht32f675x5_r2\bsp_uart_irt;..\..\..\..\..\..\sources\components\ht32f675x5_r2\gd60932;..\..\..\..\..\..\sources\components\ht32f675x5_r2\ntc;..\..\..\..\..\..\sources\components\ht32f675x5_r2\temp_fusion;..\..\..\..\..\..\sources\mem_cfg;..\..\config;.\RTE\_ble_peripheral_mp
  asm define: __MAIN_PROCESSOR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\ble_peripheral_mp.sct
  link misc: --entry=Reset_Handler --keep=g_boot2LibCode --keep=g_u8CpAppCode
  group Startup Code
    ../../../../../../sources/device/ht32f675x5/Source/ARM/: startup_ARMCM33.s
    ../../../../../../sources/device/ht32f675x5/Source/: system_ARMCM33.c
  group lib
    ../../../../../../libraries/rom/: ht32f675x5_rom_lib_mp_r2.lib
    ../../../../../../libraries/patch/: ht32f675x5_patch_lib_mp_r2.lib
    ../../../../../../libraries/boot2/: ht32f675x5_boot2_lib_r2_v1.1.c
    ../cp/: app_code_cp.c
  group components
    ../../../../../../sources/components/ht32f675x5_r2/app_debug/: app_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/err_debug/: err_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/lpwr_ctrl/: lpwr_ctrl.c
  group imu_sdk
    ../../../../../../sources/components/ht32f675x5_r2/bsp_spi/: bsp_spi.c
    ../../../../../../sources/components/ht32f675x5_r2/lsm6dsow/: lsm6dsow.c
    ../../../../../../sources/components/ht32f675x5_r2/ist8310/: ist8310.c
    ../../../../../../sources/components/ht32f675x5_r2/imu9dof/: imu9dof.c
    ../../../../../../sources/components/ht32f675x5_r2/bsp_uart_irt/: bsp_uart_irt.c
    ../../../../../../sources/components/ht32f675x5_r2/gd60932/: gd60932.c
    ../../../../../../sources/components/ht32f675x5_r2/ntc/: ntc.c
    ../../../../../../sources/components/ht32f675x5_r2/temp_fusion/: temp_fusion.c
    ../../../../../../sources/components/ht32f675x5_r2/ahrs/: ahrs.c ahrs_madgwick.c ahrs_ekf.c
    ../../../../../../sources/components/ht32f675x5_r2/ble_sensor/: ble_sensor_proto.c ble_sensor_ipc.c
    ../../../../../../sources/components/ht32f675x5_r2/ipc_general/: ipc_general_queue.c
    ../../../../../../sources/components/ht32f675x5_r2/msg_queue/: msg_queue.c
  group main
    ../../../../../../sources/projects_source/ble_examples/ble_peripheral/ht32f675x5_r2/main/mp/: main.c
software components: CMSIS:CORE 5.4.0
