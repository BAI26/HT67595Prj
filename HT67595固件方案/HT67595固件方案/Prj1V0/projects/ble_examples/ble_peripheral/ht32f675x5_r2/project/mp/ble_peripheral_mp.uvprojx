# Keil uVision project ble_peripheral_mp.uvprojx, settings and files
target ble_peripheral_mp (6150000::V6.15::ARMCLANG)
  device: HT32F67595_28LGA:CM33 Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ble_peripheral_mp +hex
  AfterMake: .\ble_peripheral_mp.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=7 wLevel=3
  c define: __MAIN_PROCESSOR HT32F67595_EVB TF_LITE_STATIC_MEMORY
  c misc: -fno-rtti -fno-exceptions
  c include: ..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\..\..\sources\device\ht32f675x5\Include;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\register;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hw\inc;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hal\inc;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ext_flash;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hw\inc;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hal\inc;..\..\..\..\..\..\sources\boards;..\..\..\..\..\..\sources\components\ht32f675x5_r2\app_debug;..\..\..\..\..\..\sources\components\ht32f675x5_r2\err_debug;..\..\..\..\..\..\sources\components\ht32f675x5_r2\fw_upgrade;..\..\..\..\..\..\sources\components\ht32f675x5_r2\lpwr_ctrl;..\..\..\..\..\..\sources\components\ht32f675x5_r2\rom_callback;..\..\..\..\..\..\sources\components\ht32f675x5_r2\utility;..\..\..\..\..\..\sources\mem_cfg;..\..\config;.\RTE\_ble_peripheral_mp;..\..\..\..\..\..\third_party\tflm-tree;..\..\..\..\..\..\third_party\tflm-tree\third_party\flatbuffers\include;..\..\..\..\..\..\third_party\tflm-tree\third_party\gemmlowp;..\..\..\..\..\..\third_party\tflm-tree\third_party\ruy;..\..\..\..\..\..\third_party\tflm-tree\third_party\kissfft;..\..\..\..\..\..\sources\components\ht32f675x5_r2\tflm_app
  asm define: __MAIN_PROCESSOR
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\ble_peripheral_mp.sct
  link misc: --entry=Reset_Handler --keep=g_boot2LibCode --keep=g_u8CpAppCode
  group Startup Code
    ../../../../../../sources/device/ht32f675x5/Source/ARM/: startup_ARMCM33.s
    ../../../../../../sources/device/ht32f675x5/Source/: system_ARMCM33.c
  group lib
    ../../../../../../libraries/rom/: ht32f675x5_rom_lib_mp_r2.lib
    ../../../../../../libraries/patch/: ht32f675x5_patch_lib_mp_r2.lib
    ../../../../../../libraries/boot2/: ht32f675x5_boot2_lib_r2_v1.1.c
    ../cp/: app_code_cp.c
  group components
    ../../../../../../sources/components/ht32f675x5_r2/app_debug/: app_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/err_debug/: err_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/lpwr_ctrl/: lpwr_ctrl.c
  group main
    ../../../../../../sources/projects_source/ble_examples/ble_peripheral/ht32f675x5_r2/main/mp/: main.c
  group tflite_micro
    ../../../../../../third_party/tflm-tree/tensorflow/lite/micro/: debug_log.cc flatbuffer_utils.cc hexdump.cc memory_helpers.cc micro_allocation_info.cc micro_allocator.cc micro_context.cc micro_interpreter.cc micro_interpreter_context.cc micro_interpreter_graph.cc micro_log.cc micro_op_resolver.cc micro_profiler.cc micro_resource_variable.cc micro_time.cc micro_utils.cc system_setup.cc
    ../../../../../../third_party/tflm-tree//tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.cc micro_error_reporter.cc
    ../../../../../../third_party/tflm-tree//tensorflow/lite/core/api/: flatbuffer_conversions.cc
    ../../../../../../third_party/tflm-tree//tensorflow/lite/core/c/: common.cc
    ../../../../../../third_party/tflm-tree//tensorflow/lite/kernels/internal/: tensor_ctypes.cc quantization_util.cc portable_tensor_utils.cc
    ../../../../../../third_party/tflm-tree//tensorflow/lite/micro/arena_allocator/: single_arena_buffer_allocator.cc persistent_arena_buffer_allocator.cc non_persistent_arena_buffer_allocator.cc
    ../../../../../../third_party/tflm-tree//tensorflow/lite/micro/memory_planner/: linear_memory_planner.cc greedy_memory_planner.cc
    ../../../../../../third_party/tflm-tree//tensorflow/compiler/mlir/lite/schema/: schema_utils.cc
    ../../../../../../third_party/tflm-tree/tensorflow/compiler/mlir/lite/core/api/: error_reporter.cc
    ../../../../../../third_party/tflm-tree//tensorflow/lite/micro/kernels/: fully_connected.cc fully_connected_common.cc kernel_util.cc
    ../../../../../../sources/components/ht32f675x5_r2/tflm_app//: tflm_infer.cpp hello_world_model_data.cc
    ../../../../../../third_party/tflm-tree//tensorflow/lite/kernels/internal/reference/: portable_tensor_utils.cc
software components: CMSIS:CORE 5.4.0
